# Keil uVision project task2.uvproj, settings and files
target Task1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: task1 +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\Drivers\Driver_Digits;..\Drivers\Driver_Key;..\Drivers\Driver_LCD;..\Drivers\Driver_ADDA;..\Application;..\Application\SysConfig;..\Application\Delay;..\Application\GUI;..\Application\Control;D:\Keil\C51\INC;..\Application\PID
  group Application
    ../Application/GUI/: gui.c
    ../Application/: main.c
    ../Application/Delay/: delay.c
    ../Application/Control/: control.c
    ../Application/PID/: pid.c
  group SysConfig
    ../: STARTUP.A51
    ../Application/SysConfig/: sysconfig.c
  group Drivers
    ../Drivers/Driver_LCD/: driver_lcd.c
    ../Drivers/Driver_Key/: driver_key.c
    ../Drivers/Driver_Digits/: driver_digits.c
    ../Drivers/Driver_ADDA/: driver_adda.c
